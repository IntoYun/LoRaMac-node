# Keil uVision project BootLoader.uvprojx, settings and files
target Bootloader (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151CBxxA STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Bootloader
  AfterMake: C:\keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin -o  .\Objects\Bootloader.bin .\Objects\Bootloader.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L151xBA  USE_NO_TIMER
  c include: ..\..\..\src;..\..\..\src\boards;..\..\..\src\boards\IntoRobot-Ant;..\..\..\src\boards\IntoRobot-Ant\cmsis;..\..\..\src\boards\IntoRobot-Ant\usb\dfu\inc;..\..\..\src\boards\mcu\stm32;..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\src\boards\mcu\stm32\STM32L1xx_HAL_Driver\Inc;..\..\..\src\boards\mcu\stm32\STM32_USB_Device_Library\Class\DFU\Inc;..\..\..\src\boards\mcu\stm32\STM32_USB_Device_Library\Core\Inc;..\..\..\src\system
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group apps
    ../../../src/apps/BootLoader/IntoRobot-Ant/: main.c
  group boards
    ../../../src/boards/IntoRobot-Ant/: gpio-board.c delay-board.c
    ../../../src/boards/IntoRobot-Ant/cmsis/: system_stm32l1xx.c
    ../../../src/boards/IntoRobot-Ant/cmsis/arm-std/: startup_stm32l151xba.s
    ../../../src/boards/IntoRobot-Ant/usb/dfu/src/: usbd_conf.c usbd_desc.c usbd_dfu_flash.c
  group boards\mcu
    ../../../src/boards/mcu/stm32/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c
    ../../../src/boards/mcu/stm32/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../../src/boards/mcu/stm32/STM32_USB_Device_Library/Class/DFU/Src/: usbd_dfu.c
    ../../../src/boards/mcu/stm32/: sysIrqHandlers.c
  group system
    ../../../src/system/: gpio.c
